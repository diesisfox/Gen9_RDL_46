<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Gen9_RDL_46.ewp</path>
  </project>
  <batchBuild />
</workspace>
